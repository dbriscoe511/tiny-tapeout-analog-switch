**************************************
* SPICE STIMULI FILE
* generated from
**************************************

VSW_ON SW_ON 0 PWL 0n 0 1000n 0 1001n VCC 2000n VCC 2001n 0 3001n
+0 3002n VCC 4001n VCC 4002n 0
VLOAD_ON LOAD_ON 0 PWL 0n 0 3000n 0 3001n 2
Vvdd vdd 0 PWL 0n VCC
VVSS VSS 0 PWL 0n 0
VSW+ SW+ 0 PWL 0n 0.5
